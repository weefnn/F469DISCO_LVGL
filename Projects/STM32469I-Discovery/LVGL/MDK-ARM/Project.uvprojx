# Keil uVision project Project.uvprojx, settings and files
target STM32469I_DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x2000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32469I_DISCO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --C99
  c include: ..\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\LittlevGL;..\..\..\..\Drivers\BSP\STM32469I-Discovery;..\LittlevGL\lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_dac.c stm32f4xx_hal_sd.c stm32f4xx_hal_sram.c stm32f4xx_ll_usb.c stm32f4xx_hal_irda.c stm32f4xx_hal_pwr.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_nand.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_nor.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pccard.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_sdram.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2s.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_qspi.c stm32f4xx_hal_sai.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_usart.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_cec.c stm32f4xx_hal_rcc.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_hash.c
  group Example/MDK-ARM
    ./: startup_stm32f469xx.s
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c
    ../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group hal_stm_lvgl
    ../LittlevGL/hal_stm_lvgl/tft/: tft.c
    ../LittlevGL/hal_stm_lvgl/touchpad/: touchpad.c
  group lv_examples
    ../LittlevGL/lv_examples/lv_apps/demo/: demo.c img_bubble_pattern.c
    ../LittlevGL/lv_examples/lv_apps/benchmark/: benchmark.c benchmark_bg.c
    ../LittlevGL/lv_examples/lv_apps/sysmon/: sysmon.c
    ../LittlevGL/lv_examples/lv_tutorial/4_themes/: lv_tutorial_themes.c
    ../LittlevGL/lv_examples/lv_tutorial/2_objects/: lv_tutorial_objects.c
  group lvgl
    ../LittlevGL/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../LittlevGL/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../LittlevGL/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../LittlevGL/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LittlevGL/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../LittlevGL/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../LittlevGL/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group Utilities
    ../../../../Drivers/BSP/STM32469I-Discovery/: libPDMFilter_CM4_Keil_wc16.lib
  group F469i
    ../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c stm32469i_discovery_audio.c stm32469i_discovery_eeprom.c stm32469i_discovery_lcd.c stm32469i_discovery_qspi.c stm32469i_discovery_sd.c stm32469i_discovery_sdram.c stm32469i_discovery_ts.c
software components: CMSIS:CORE 4.1.0
